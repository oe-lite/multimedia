require gst-plugins.inc

DEPENDS += "gst-plugins-base"
SRC_URI = "http://core.fluendo.com/gstreamer/src/${PN}/${PN}-${PV}.tar.bz2"
