require ${BPN}.inc
SRC_URI += "file://check_fix.patch"
SRC_URI += "file://gst-inspect-check-error.patch"
